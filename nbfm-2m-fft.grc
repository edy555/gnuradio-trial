<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>nbfm_2m_fft</value></param>
<param><key>title</key><value>NBFM RX 2m with FFT</value></param>
<param><key>author</key><value>edy555</value></param>
<param><key>description</key><value>Save/Load freq from a config file.</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency (Hz)</value></param>
<param><key>value</key><value>freq_init</value></param>
<param><key>min</key><value>144e6</value></param>
<param><key>max</key><value>146e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain (db)</value></param>
<param><key>value</key><value>80</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Squelch (db)</value></param>
<param><key>value</key><value>-20</value></param>
<param><key>min</key><value>-100</value></param>
<param><key>max</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>freq_init</value></param>
<param><key>value</key><value>145.1e6</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config-nbfm-2m.conf</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>writeback</key><value>freq</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>32000</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_nbfm_rx</key>
<param><key>id</key><value>blks2_nbfm_rx_0</value></param>
<param><key>audio_rate</key><value>32000</value></param>
<param><key>quad_rate</key><value>32000</value></param>
<param><key>tau</key><value>50e-6</value></param>
<param><key>max_dev</key><value>5e3</value></param>
</block>
<block>
<key>gr_simple_squelch_cc</key>
<param><key>id</key><value>gr_simple_squelch_cc_0</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>alpha</key><value>0.0001</value></param>
</block>
<block>
<key>rtl2832_source</key>
<param><key>id</key><value>rtl2832_source_0</value></param>
<param><key>verbose</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>bandwidth</key><value>8e6</value></param>
<param><key>relative_gain</key><value>True</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>gain_mode</key><value></value></param>
<param><key>auto_gain_mode</key><value>False</value></param>
<param><key>usb_vid</key><value>0x0</value></param>
<param><key>usb_pid</key><value>0x0</value></param>
<param><key>tuner_name</key><value></value></param>
<param><key>read_length</key><value>0</value></param>
<param><key>xfer_timeout</key><value>0</value></param>
<param><key>use_buffer</key><value>True</value></param>
<param><key>buf_mul</key><value>0</value></param>
<param><key>buf_level</key><value>0</value></param>
<param><key>fir_coeffs</key><value>[]</value></param>
<param><key>xtal_freq</key><value>0</value></param>
<param><key>status_out</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2048000</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>64</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>5e3</value></param>
<param><key>width</key><value>2e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_nbfm_rx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>gr_simple_squelch_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_simple_squelch_cc_0</source_block_id><sink_block_id>blks2_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtl2832_source_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
